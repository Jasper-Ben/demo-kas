LICENSE = "CLOSED"
LIC_FILES_CHKSUM = ""

inherit shared-code
VAR = "l"
